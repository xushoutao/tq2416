# Keil uVision project STM32F103_WTD.uvproj, settings and files
target STM32F103_WTD (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_WTD +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Libraries\simplelink\include;..\..\..\..\Libraries\simplelink\oslib;..\..\..\..\Utilities\STM32_BSP\STM32F10x_WTD_IF;..\..\..\..\Utilities\STM32_BSP\STM32F10x_Driver;..\..\..\..\Utilities\Third_Party\FreeRTOS\portable\keil\ARM_CM3;..\..\..\..\Utilities\Third_Party\FreeRTOS\include;..\..\..\..\Utilities\Third_Party\FreeModbus\modbus\include;..\..\..\..\Utilities\Third_Party\FreeModbus\port;..\..\..\..\Utilities\Third_Party\FreeModbus\modbus\ascii;..\..\..\..\Utilities\Third_Party\FreeModbus\modbus\rtu;..\..\..\..\Utilities\Third_Party\SimpleLink\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000100 size 0x4f00
  group STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../src/: main.c stm32f10x_it.c startup_stm32f10x_freertos.s simplelink_app.c
  group FreeRTOS
    ../../../../Utilities/Third_Party/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../../../../Utilities/Third_Party/FreeRTOS/portable/MemMang/: heap_2.c
    ../../../../Utilities/Third_Party/FreeRTOS/portable/keil/ARM_CM3/: port.c
  group STM32F10x_Driver
    ../../../../Utilities/STM32_BSP/STM32F10x_Driver/: stm32f10x_wtd_74hc165.c stm32f10x_wtd_74hc595.c stm32f10x_wtd_eeprom.c stm32f10x_wtd_led.c stm32f10x_wtd_spi.c stm32f10x_wtd_usart.c stm32f10x_wtd_int.c
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32F10x_WTD_IF
    ../../../../Utilities/STM32_BSP/STM32F10x_WTD_IF/: stm32f10x_wtd_digital_if.c stm32f10x_wtd_relay_if.c
  group FreeModbus
    ../../../../Utilities/Third_Party/FreeModbus/: mbfunc.c mbmasterfunc.c
    ../../../../Utilities/Third_Party/FreeModbus/port/: portevent.c portother.c portserial.c porttimer.c
    ../../../../Utilities/Third_Party/FreeModbus/modbus/: mb.c
    ../../../../Utilities/Third_Party/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../../../../Utilities/Third_Party/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../../../Utilities/Third_Party/FreeModbus/modbus/ascii/: mbascii.c
  group Simplelink
    ../../../../Libraries/simplelink/source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
    ../../../../Libraries/simplelink/oslib/: osi_freertos.c
    ../../../../Utilities/Third_Party/SimpleLink/src/: cc_pal.c
